# IAR project pdl_template.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: MB9BF124L Cypress MB9BF124L
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\common; ..\..\template\source; ..\..\driver; ..\..\utility; ..\..\template\source; ..\..\template\IAR\source; G:\Haier\Project\HYCD-469\Code\Disp Board\0271800139A_Program\trunk\mb9bf524L_template\template\IAR\source\Wifi
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: pdl_template.hex
  ILINK.IlinkOutputFile: pdl_template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF524L Spansion MB9BF524L
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\common; ..\..\template\source; ..\..\driver; ..\..\utility; ..\..\app; ..\..\highlevel; ..\..\midware
  ICCARM.CCOptLevel: 0
  group common
    ../../common/: system_fm3.c
  group driver
    ../../driver/adc/: adc.c
    ../../driver/bt/: bt.c
    ../../driver/can/: can.c can_pre.c canfd.c
    ../../driver/clk/: clk.c
    ../../driver/cr/: cr.c
    ../../driver/crc/: crc.c
    ../../driver/csv/: csv.c
    ../../driver/dac/: dac.c
    ../../driver/dma/: dma.c
    ../../driver/dstc/: dstc.c
    ../../driver/dt/: dt.c
    ../../driver/flash/: dualflash.c mainflash.c workflash.c
    ../../driver/exint/: exint.c
    ../../driver/extif/: extif.c
    ../../driver/hbif/: hbif.c
    ../../driver/hsspi/: hsspi.c
    ../../driver/wdg/: hwwdg.c swwdg.c
    ../../driver/i2cs/: i2cs.c
    ../../driver/i2s/: i2s.c
    ../../driver/i2sl/: i2sl.c
    ../../driver/icc/: icc.c
    ../../driver/: interrupts_fm0p.c interrupts_fm3.c interrupts_fm4.c pdl.c
    ../../driver/lcd/: lcd.c
    ../../driver/lpm/: lpm.c
    ../../driver/lvd/: lvd.c
    ../../driver/mfs/: mfs.c
    ../../driver/mft/: mft_adcmp.c mft_frt.c mft_icu.c mft_ocu.c mft_wfg.c
    ../../driver/pcrc/: pcrc.c
    ../../driver/ppg/: ppg.c
    ../../driver/qprc/: qprc.c
    ../../driver/rc/: rc.c
    ../../driver/reset/: reset.c
    ../../driver/rtc/: rtc.c
    ../../driver/sdif/: sdif.c
    ../../driver/uid/: uid.c
    ../../driver/vbat/: vbat.c
    ../../driver/wc/: wc.c
  group source
    source/Wifi/: Coupler.c esp8266.c
    source/: Disp.c Disp.H Init_config.c logicsub.c logicsub.H main.c Program_Cfg.h Typedefine.h
    ./: startup_fm.s
    ../../../: 版本记录.txt
